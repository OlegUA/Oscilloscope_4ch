# Keil uVision project Oscilloscope.uvproj, settings and files
target Oscilloscope (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) IRAM2(0x10000000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(72000000) ELITTLE
  output: Oscilloscope +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F30X, USE_STM32F3DISCOVERY
  c include: ..\inc;..\..\STM32F3_Libraries\Libraries\CMSIS\Include;..\..\STM32F3_Libraries\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\STM32F3_Libraries\Libraries\STM32F30x_StdPeriph_Driver\inc;..\..\STM32F3_Libraries\Utilities\STM32F3_Discovery;..\..\ST7735\src;..\vcp\inc;..\adc;..\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group CMSIS
    ../../STM32F3_Libraries/Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s
  group usb
    ../../STM32F3_Libraries/Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group DPL
    ../../STM32F3_Libraries/Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_usart.c stm32f30x_adc.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_i2c.c stm32f30x_spi.c
  group F3Discovery
    ../../STM32F3_Libraries/Utilities/STM32F3_Discovery/: stm32f3_discovery.c
  group vcp
    ../vcp/src/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c vcp_it.c vcp_hw_config.c
  group adc
    ../adc/: acquire.c
  group src
    ../../STM32F3_Libraries/Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/: system_stm32f30x.c
    ../src/: main.c redirect2usart1.c
